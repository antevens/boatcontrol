# Repository antevens/boatcontrol (continued)

## KiCad design boatcontrol/boatcontrol.kicad_pcb (continued)

Schematic: 6AmpCircuit.sch, Boat Control Hat

Parts:
CB8701: T9-818 6A; Schurter_Circuit_Breaker
D8701: 20mA R/G CA; LED_D5.0mm-3
K8701: G5RL-K1A-E-DC12; RELAY_G5RL-K1A-E-DC12
SW8701, SW8702: ESB30; SW_PUSH_ESB30_DPDT

Connections:
+12P: D8701.2 (K), K8701.9 (C9); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC1/DISABLED_INDICATOR: SW8701.3 (C), SW8702.3 (C)
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC1/OFF: SW8701.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC1/OFF_COIL: K8701.8 (C8), SW8702.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC1/OFF_LED: D8701.3 (A2); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC1/OFF_TO_ON: SW8701.5 (B), SW8702.1 (A)
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC1/ON: SW8702.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC1/ON_COIL: K8701.1 (C1), SW8701.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC1/ON_LED: D8701.1 (A1); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC1/ON_TO_OFF: SW8701.1 (A), SW8702.5 (B)
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC1/TO_FUSE: CB8701.P1, K8701.4 (NO), K8701.5 (NO)
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/OUT_C1: CB8701.P2; also elsewhere on the board
AC: K8701.3 (NC), K8701.6 (NC); also elsewhere on the board
GND: SW8701.6 (C), SW8702.6 (C); also elsewhere on the board

Parts of its further copies:
CB5701, CB5801, CB5901, CB6001, CB8401, CB8501, CB8601: T9-818 6A; Schurter_Circuit_Breaker
D5701, D5801, D5901, D6001, D8401, D8501, D8601: 20mA R/G CA; LED_D5.0mm-3
K5701, K5801, K5901, K6001, K8401, K8501, K8601: G5RL-K1A-E-DC12; RELAY_G5RL-K1A-E-DC12
SW5701, SW5702, SW5801, SW5802, SW5901, SW5902, SW6001, SW6002, SW8401, SW8402, SW8501, SW8502, SW8601, SW8602: ESB30; SW_PUSH_ESB30_DPDT

Connections of its further copies:
+12L: K5701.3 (NC), K5701.6 (NC), K5801.3 (NC), K5801.6 (NC), K5901.3 (NC), K5901.6 (NC), K6001.3 (NC), K6001.6 (NC); also elsewhere on the board
+12P: D5701.2 (K), D5801.2 (K), D5901.2 (K), D6001.2 (K), D8401.2 (K), D8501.2 (K), D8601.2 (K), K5701.9 (C9), K5801.9 (C9), K5901.9 (C9), K6001.9 (C9), K8401.9 (C9), K8501.9 (C9), K8601.9 (C9); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC1/DISABLED_INDICATOR: SW6001.3 (C), SW6002.3 (C)
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC1/OFF: SW6001.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC1/OFF_COIL: K6001.8 (C8), SW6002.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC1/OFF_LED: D6001.3 (A2); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC1/OFF_TO_ON: SW6001.5 (B), SW6002.1 (A)
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC1/ON: SW6002.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC1/ON_COIL: K6001.1 (C1), SW6001.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC1/ON_LED: D6001.1 (A1); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC1/ON_TO_OFF: SW6001.1 (A), SW6002.5 (B)
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC1/TO_FUSE: CB6001.P1, K6001.4 (NO), K6001.5 (NO)
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC2/DISABLED_INDICATOR: SW5901.3 (C), SW5902.3 (C)
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC2/OFF: SW5901.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC2/OFF_COIL: K5901.8 (C8), SW5902.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC2/OFF_LED: D5901.3 (A2); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC2/OFF_TO_ON: SW5901.5 (B), SW5902.1 (A)
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC2/ON: SW5902.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC2/ON_COIL: K5901.1 (C1), SW5901.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC2/ON_LED: D5901.1 (A1); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC2/ON_TO_OFF: SW5901.1 (A), SW5902.5 (B)
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC2/TO_FUSE: CB5901.P1, K5901.4 (NO), K5901.5 (NO)
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC3/DISABLED_INDICATOR: SW5801.3 (C), SW5802.3 (C)
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC3/OFF: SW5801.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC3/OFF_COIL: K5801.8 (C8), SW5802.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC3/OFF_LED: D5801.3 (A2); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC3/OFF_TO_ON: SW5801.5 (B), SW5802.1 (A)
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC3/ON: SW5802.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC3/ON_COIL: K5801.1 (C1), SW5801.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC3/ON_LED: D5801.1 (A1); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC3/ON_TO_OFF: SW5801.1 (A), SW5802.5 (B)
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC3/TO_FUSE: CB5801.P1, K5801.4 (NO), K5801.5 (NO)
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC4/DISABLED_INDICATOR: SW5701.3 (C), SW5702.3 (C)
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC4/OFF: SW5701.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC4/OFF_COIL: K5701.8 (C8), SW5702.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC4/OFF_LED: D5701.3 (A2); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC4/OFF_TO_ON: SW5701.5 (B), SW5702.1 (A)
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC4/ON: SW5702.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC4/ON_COIL: K5701.1 (C1), SW5701.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC4/ON_LED: D5701.1 (A1); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC4/ON_TO_OFF: SW5701.1 (A), SW5702.5 (B)
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/6AC4/TO_FUSE: CB5701.P1, K5701.4 (NO), K5701.5 (NO)
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/OUT_C1: CB6001.P2; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/OUT_C2: CB5901.P2; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/OUT_C3: CB5801.P2; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/OUT_C4: CB5701.P2; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC2/DISABLED_INDICATOR: SW8601.3 (C), SW8602.3 (C)
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC2/OFF: SW8601.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC2/OFF_COIL: K8601.8 (C8), SW8602.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC2/OFF_LED: D8601.3 (A2); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC2/OFF_TO_ON: SW8601.5 (B), SW8602.1 (A)
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC2/ON: SW8602.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC2/ON_COIL: K8601.1 (C1), SW8601.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC2/ON_LED: D8601.1 (A1); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC2/ON_TO_OFF: SW8601.1 (A), SW8602.5 (B)
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC2/TO_FUSE: CB8601.P1, K8601.4 (NO), K8601.5 (NO)
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC3/DISABLED_INDICATOR: SW8501.3 (C), SW8502.3 (C)
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC3/OFF: SW8501.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC3/OFF_COIL: K8501.8 (C8), SW8502.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC3/OFF_LED: D8501.3 (A2); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC3/OFF_TO_ON: SW8501.5 (B), SW8502.1 (A)
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC3/ON: SW8502.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC3/ON_COIL: K8501.1 (C1), SW8501.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC3/ON_LED: D8501.1 (A1); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC3/ON_TO_OFF: SW8501.1 (A), SW8502.5 (B)
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC3/TO_FUSE: CB8501.P1, K8501.4 (NO), K8501.5 (NO)
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC4/DISABLED_INDICATOR: SW8401.3 (C), SW8402.3 (C)
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC4/OFF: SW8401.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC4/OFF_COIL: K8401.8 (C8), SW8402.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC4/OFF_LED: D8401.3 (A2); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC4/OFF_TO_ON: SW8401.5 (B), SW8402.1 (A)
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC4/ON: SW8402.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC4/ON_COIL: K8401.1 (C1), SW8401.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC4/ON_LED: D8401.1 (A1); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC4/ON_TO_OFF: SW8401.1 (A), SW8402.5 (B)
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/6AC4/TO_FUSE: CB8401.P1, K8401.4 (NO), K8401.5 (NO)
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/OUT_C2: CB8601.P2; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/OUT_C3: CB8501.P2; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/OUT_C4: CB8401.P2; also elsewhere on the board
AC: K8401.3 (NC), K8401.6 (NC), K8501.3 (NC), K8501.6 (NC), K8601.3 (NC), K8601.6 (NC); also elsewhere on the board
GND: SW5701.6 (C), SW5702.6 (C), SW5801.6 (C), SW5802.6 (C), SW5901.6 (C), SW5902.6 (C), SW6001.6 (C), SW6002.6 (C), SW8401.6 (C), SW8402.6 (C), SW8501.6 (C), SW8502.6 (C), SW8601.6 (C), SW8602.6 (C); also elsewhere on the board

Notes on the sheet:
Buttons offer manual overide of relays using direct 12V. There is no timing/pulse circuit when operating the switches so care should be taken not to energise relay coils for more than a few seconds. Setting each coil to "on" will disable the opposing coil to prevent both coils from being energnized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

Schematic: 10AmpCircuit.sch, Boat Control Hat

Parts:
CB6801: T9-818 10A; Schurter_Circuit_Breaker
D6801: 20mA R/G CA; LED_D5.0mm-3
K6801: G5RL-K1A-E-DC12; RELAY_G5RL-K1A-E-DC12
SW6801, SW6802: ESB30; SW_PUSH_ESB30_DPDT

Connections:
+12P: D6801.2 (K), K6801.9 (C9); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC1/DISABLED_INDICAT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: SW6801.3 (C), SW6802.3 (C)
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC1/OFF: SW6801.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC1/OFF_COIL: K6801.8 (C8), SW6802.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC1/OFF_LED: D6801.3 (A2); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC1/OFF_TO_ON: SW6801.5 (B), SW6802.1 (A)
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC1/ON: SW6802.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC1/ON_COIL: K6801.1 (C1), SW6801.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC1/ON_LED: D6801.1 (A1); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC1/ON_TO_OFF: SW6801.1 (A), SW6802.5 (B)
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC1/TO_FUSE: CB6801.P1, K6801.4 (NO), K6801.5 (NO)
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/OUT_C1: CB6801.P2; also elsewhere on the board
AC: K6801.3 (NC), K6801.6 (NC); also elsewhere on the board
GND: SW6801.6 (C), SW6802.6 (C); also elsewhere on the board

Parts of its further copies:
CB6701, CB7601, CB7701: T9-818 10A; Schurter_Circuit_Breaker
D6701, D7601, D7701: 20mA R/G CA; LED_D5.0mm-3
K6701, K7601, K7701: G5RL-K1A-E-DC12; RELAY_G5RL-K1A-E-DC12
SW6701, SW6702, SW7601, SW7602, SW7701, SW7702: ESB30; SW_PUSH_ESB30_DPDT

Connections of its further copies:
+12L: K7601.3 (NC), K7601.6 (NC), K7701.3 (NC), K7701.6 (NC); also elsewhere on the board
+12P: D6701.2 (K), D7601.2 (K), D7701.2 (K), K6701.9 (C9), K7601.9 (C9), K7701.9 (C9); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC1/DISABLED_INDICATOR: SW7701.3 (C), SW7702.3 (C)
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC1/OFF: SW7701.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC1/OFF_COIL: K7701.8 (C8), SW7702.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC1/OFF_LED: D7701.3 (A2); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC1/OFF_TO_ON: SW7701.5 (B), SW7702.1 (A)
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC1/ON: SW7702.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC1/ON_COIL: K7701.1 (C1), SW7701.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC1/ON_LED: D7701.1 (A1); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC1/ON_TO_OFF: SW7701.1 (A), SW7702.5 (B)
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC1/TO_FUSE: CB7701.P1, K7701.4 (NO), K7701.5 (NO)
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC2/DISABLED_INDICATOR: SW7601.3 (C), SW7602.3 (C)
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC2/OFF: SW7601.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC2/OFF_COIL: K7601.8 (C8), SW7602.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC2/OFF_LED: D7601.3 (A2); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC2/OFF_TO_ON: SW7601.5 (B), SW7602.1 (A)
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC2/ON: SW7602.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC2/ON_COIL: K7601.1 (C1), SW7601.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC2/ON_LED: D7601.1 (A1); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC2/ON_TO_OFF: SW7601.1 (A), SW7602.5 (B)
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/10AC2/TO_FUSE: CB7601.P1, K7601.4 (NO), K7601.5 (NO)
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/OUT_C1: CB7701.P2; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/OUT_C2: CB7601.P2; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC2/DISABLED_INDICAT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: SW6701.3 (C), SW6702.3 (C)
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC2/OFF: SW6701.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC2/OFF_COIL: K6701.8 (C8), SW6702.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC2/OFF_LED: D6701.3 (A2); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC2/OFF_TO_ON: SW6701.5 (B), SW6702.1 (A)
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC2/ON: SW6702.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC2/ON_COIL: K6701.1 (C1), SW6701.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC2/ON_LED: D6701.1 (A1); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC2/ON_TO_OFF: SW6701.1 (A), SW6702.5 (B)
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/10AC2/TO_FUSE: CB6701.P1, K6701.4 (NO), K6701.5 (NO)
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/OUT_C2: CB6701.P2; also elsewhere on the board
AC: K6701.3 (NC), K6701.6 (NC); also elsewhere on the board
GND: SW6701.6 (C), SW6702.6 (C), SW7601.6 (C), SW7602.6 (C), SW7701.6 (C), SW7702.6 (C); also elsewhere on the board

Notes on the sheet:
Buttons offer manual overide of relays using direct 12V. There is no timing/pulse circuit when operating the switches so care should be taken not to energise relay coils for more than a few seconds. Setting each coil to "on" will disable the opposing coil to prevent both coils from being energnized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

Schematic: 16AmpCircuit.sch, Boat Control Hat

Parts:
CB6601: T9-818 16A; Schurter_Circuit_Breaker
D6601: 20mA R/G CA; LED_D5.0mm-3
K6601: G5RL-K1A-E-DC12; RELAY_G5RL-K1A-E-DC12
SW6601, SW6602: ESB30; SW_PUSH_ESB30_DPDT

Connections:
+12P: D6601.2 (K), K6601.9 (C9); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC2/DISABLED_INDICAT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: SW6601.3 (C), SW6602.3 (C)
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC2/OFF: SW6601.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC2/OFF_COIL: K6601.8 (C8), SW6602.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC2/OFF_LED: D6601.3 (A2); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC2/OFF_TO_ON: SW6601.5 (B), SW6602.1 (A)
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC2/ON: SW6602.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC2/ON_COIL: K6601.1 (C1), SW6601.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC2/ON_LED: D6601.1 (A1); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC2/ON_TO_OFF: SW6601.1 (A), SW6602.5 (B)
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC2/TO_FUSE: CB6601.P1, K6601.4 (NO), K6601.5 (NO)
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/OUT_C4: CB6601.P2; also elsewhere on the board
AC: K6601.3 (NC), K6601.6 (NC); also elsewhere on the board
GND: SW6601.6 (C), SW6602.6 (C); also elsewhere on the board

Parts of its further copies:
CB6901, CB7501, CB7801: T9-818 16A; Schurter_Circuit_Breaker
D6901, D7501, D7801: 20mA R/G CA; LED_D5.0mm-3
K6901, K7501, K7801: G5RL-K1A-E-DC12; RELAY_G5RL-K1A-E-DC12
SW6901, SW6902, SW7501, SW7502, SW7801, SW7802: ESB30; SW_PUSH_ESB30_DPDT

Connections of its further copies:
+12L: K7501.3 (NC), K7501.6 (NC), K7801.3 (NC), K7801.6 (NC); also elsewhere on the board
+12P: D6901.2 (K), D7501.2 (K), D7801.2 (K), K6901.9 (C9), K7501.9 (C9), K7801.9 (C9); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC1/DISABLED_INDICATOR: SW7801.3 (C), SW7802.3 (C)
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC1/OFF: SW7801.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC1/OFF_COIL: K7801.8 (C8), SW7802.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC1/OFF_LED: D7801.3 (A2); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC1/OFF_TO_ON: SW7801.5 (B), SW7802.1 (A)
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC1/ON: SW7802.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC1/ON_COIL: K7801.1 (C1), SW7801.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC1/ON_LED: D7801.1 (A1); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC1/ON_TO_OFF: SW7801.1 (A), SW7802.5 (B)
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC1/TO_FUSE: CB7801.P1, K7801.4 (NO), K7801.5 (NO)
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC2/DISABLED_INDICATOR: SW7501.3 (C), SW7502.3 (C)
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC2/OFF: SW7501.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC2/OFF_COIL: K7501.8 (C8), SW7502.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC2/OFF_LED: D7501.3 (A2); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC2/OFF_TO_ON: SW7501.5 (B), SW7502.1 (A)
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC2/ON: SW7502.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC2/ON_COIL: K7501.1 (C1), SW7501.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC2/ON_LED: D7501.1 (A1); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC2/ON_TO_OFF: SW7501.1 (A), SW7502.5 (B)
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/16AC2/TO_FUSE: CB7501.P1, K7501.4 (NO), K7501.5 (NO)
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/OUT_C3: CB7801.P2; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/OUT_C4: CB7501.P2; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC1/DISABLED_INDICAT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: SW6901.3 (C), SW6902.3 (C)
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC1/OFF: SW6901.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC1/OFF_COIL: K6901.8 (C8), SW6902.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC1/OFF_LED: D6901.3 (A2); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC1/OFF_TO_ON: SW6901.5 (B), SW6902.1 (A)
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC1/ON: SW6902.4 (A); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC1/ON_COIL: K6901.1 (C1), SW6901.2 (B); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC1/ON_LED: D6901.1 (A1); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC1/ON_TO_OFF: SW6901.1 (A), SW6902.5 (B)
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/16AC1/TO_FUSE: CB6901.P1, K6901.4 (NO), K6901.5 (NO)
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/OUT_C3: CB6901.P2; also elsewhere on the board
AC: K6901.3 (NC), K6901.6 (NC); also elsewhere on the board
GND: SW6901.6 (C), SW6902.6 (C), SW7501.6 (C), SW7502.6 (C), SW7801.6 (C), SW7802.6 (C); also elsewhere on the board

Notes on the sheet:
Buttons offer manual overide of relays using direct 12V. There is no timing/pulse circuit when operating the switches so care should be taken not to energise relay coils for more than a few seconds. Setting each coil to "on" will disable the opposing coil to prevent both coils from being energnized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

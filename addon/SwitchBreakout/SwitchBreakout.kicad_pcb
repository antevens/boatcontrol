# Repository antevens/boatcontrol (continued)

## KiCad design boatcontrol/boatcontrol.kicad_pcb (continued)

Schematic: MultiVibratorA.sch, Boat Control Hat

Parts:
C401: 0.1μF; C_Disc_D7.5mm_W5.0mm_P5.00mm
C402, C403: 1µF; C_Disc_D7.5mm_W5.0mm_P5.00mm
IC401: CD74HCT221E; DIP794W53P254L1930H508Q16N; Manufacturer_Part_Number CD74HCT221E; Mouser Part Number 595-CD74HCT221E
U2103: 74HC86

Connections:
+5V: C401.1, IC401.16 (VCC); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A1/MUX_OFF: IC401.5 (2Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A1/MUX_ON: IC401.13 (1Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A1/R1: IC401.14 (1CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A1/R2: IC401.6 (2CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A1/RC1: IC401.15 (1CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A1/RC2: IC401.7 (2CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/DIG_OFF_C3: U2103.4; also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/DIG_ON_C3: U2103.1; also elsewhere on the board
GND: C401.2, C402.1, C403.1, IC401.1 (~1A), IC401.8 (GND), IC401.9 (~2A); also elsewhere on the board
unnamed: IC401.4 (~1Q), IC401.11 (~2R)
unnamed: IC401.3 (~1R), IC401.12 (~2Q)

Parts of its further copies:
C501, C601, C701, C1301, C1401, C1501, C1601, C2201, C2301, C2401, C2501, C3101, C3201, C3301, C3401, C5301, C5401, C5501, C5601, C6201, C6301, C6401, C6501, C7101, C7201, C7301, C7401, C8001, C8101, C8201, C8301: 0.1μF; C_Disc_D7.5mm_W5.0mm_P5.00mm
C602, C603, C1302, C1303, C1502, C1503, C2202, C2203, C2402, C2403, C3102, C3103, C3302, C3303, C5302, C5303, C5502, C5503, C6202, C6203, C6402, C6403, C7102, C7103, C7302, C7303, C8002, C8003, C8202, C8203: 1µF; C_Disc_D7.5mm_W5.0mm_P5.00mm
IC501, IC601, IC701, IC1301, IC1401, IC1501, IC1601, IC2201, IC2301, IC2401, IC2501, IC3101, IC3201, IC3301, IC3401, IC5301, IC5401, IC5501, IC5601, IC6201, IC6301, IC6401, IC6501, IC7101, IC7201, IC7301, IC7401, IC8001, IC8101, IC8201, IC8301: CD74HCT221E; DIP794W53P254L1930H508Q16N; Manufacturer_Part_Number CD74HCT221E; Mouser Part Number 595-CD74HCT221E
U1202, U1203, U2102, U3002, U3003, U4002, U4003, U6102, U6103: 74HC86

Connections of its further copies:
12V_DC_C3_OFF: C603.2; also elsewhere on the board
12V_DC_C3_ON: C602.2; also elsewhere on the board
12V_DC_C5_OFF: C1303.2, U1202.5; also elsewhere on the board
12V_DC_C5_ON: C1302.2, U1202.2; also elsewhere on the board
12V_DC_C6_OFF: U1202.13; also elsewhere on the board
12V_DC_C6_ON: U1202.10; also elsewhere on the board
12V_DC_C7_OFF: C1503.2, U1203.5; also elsewhere on the board
12V_DC_C7_ON: C1502.2, U1203.2; also elsewhere on the board
12V_DC_C8_OFF: U1203.13; also elsewhere on the board
12V_DC_C8_ON: U1203.10; also elsewhere on the board
12V_DC_C9_OFF: C2203.2, U2102.5; also elsewhere on the board
12V_DC_C9_ON: C2202.2, U2102.2; also elsewhere on the board
12V_DC_C10_OFF: U2102.13; also elsewhere on the board
12V_DC_C10_ON: U2102.10; also elsewhere on the board
12V_DC_C13_OFF: C3103.2, U3002.5; also elsewhere on the board
12V_DC_C13_ON: C3102.2, U3002.2; also elsewhere on the board
12V_DC_C14_OFF: U3002.13; also elsewhere on the board
12V_DC_C14_ON: U3002.10; also elsewhere on the board
12V_DC_C15_OFF: C3303.2, U3003.5; also elsewhere on the board
12V_DC_C15_ON: C3302.2, U3003.2; also elsewhere on the board
12V_DC_C16_OFF: U3003.13; also elsewhere on the board
12V_DC_C16_ON: U3003.10; also elsewhere on the board
12V_DC_C17_OFF: C5303.2, U4002.5; also elsewhere on the board
12V_DC_C17_ON: C5302.2, U4002.2; also elsewhere on the board
12V_DC_C18_OFF: U4002.13; also elsewhere on the board
12V_DC_C18_ON: U4002.10; also elsewhere on the board
12V_DC_C19_OFF: C5503.2, U4003.5; also elsewhere on the board
12V_DC_C19_ON: C5502.2, U4003.2; also elsewhere on the board
12V_DC_C20_OFF: U4003.13; also elsewhere on the board
12V_DC_C20_ON: U4003.10; also elsewhere on the board
12V_DC_C21_OFF: C7103.2; also elsewhere on the board
12V_DC_C21_ON: C7102.2; also elsewhere on the board
12V_DC_C23_OFF: C7303.2; also elsewhere on the board
12V_DC_C23_ON: C7302.2; also elsewhere on the board
230V_AC_C1_OFF: C8003.2; also elsewhere on the board
230V_AC_C1_ON: C8002.2; also elsewhere on the board
230V_AC_C3_OFF: C8203.2; also elsewhere on the board
230V_AC_C3_ON: C8202.2; also elsewhere on the board
230V_AC_C5_OFF: C6203.2, U6102.5; also elsewhere on the board
230V_AC_C5_ON: C6202.2, U6102.2; also elsewhere on the board
230V_AC_C6_OFF: U6102.13; also elsewhere on the board
230V_AC_C6_ON: U6102.10; also elsewhere on the board
230V_AC_C7_OFF: C6403.2, U6103.5; also elsewhere on the board
230V_AC_C7_ON: C6402.2, U6103.2; also elsewhere on the board
230V_AC_C8_OFF: U6103.13; also elsewhere on the board
230V_AC_C8_ON: U6103.10; also elsewhere on the board
+5V: C501.1, C601.1, C701.1, C1301.1, C1401.1, C1501.1, C1601.1, C2201.1, C2301.1, C2401.1, C2501.1, C3101.1, C3201.1, C3301.1, C3401.1, C5301.1, C5401.1, C5501.1, C5601.1, C6201.1, C6301.1, C6401.1, C6501.1, C7101.1, C7201.1, C7301.1, C7401.1, C8001.1, C8101.1, C8201.1, C8301.1, IC501.16 (VCC), IC601.16 (VCC), IC701.16 (VCC), IC1301.16 (VCC), IC1401.16 (VCC), IC1501.16 (VCC), IC1601.16 (VCC), IC2201.16 (VCC), IC2301.16 (VCC), IC2401.16 (VCC), IC2501.16 (VCC), IC3101.16 (VCC), IC3201.16 (VCC), IC3301.16 (VCC), IC3401.16 (VCC), IC5301.16 (VCC), IC5401.16 (VCC), IC5501.16 (VCC), IC5601.16 (VCC), IC6201.16 (VCC), IC6301.16 (VCC), IC6401.16 (VCC), IC6501.16 (VCC), IC7101.16 (VCC), IC7201.16 (VCC), IC7301.16 (VCC), IC7401.16 (VCC), IC8001.16 (VCC), IC8101.16 (VCC), IC8201.16 (VCC), IC8301.16 (VCC), U1202.14 (VCC), U1203.14 (VCC), U2102.14 (VCC), U3002.14 (VCC), U3003.14 (VCC), U4002.14 (VCC), U4003.14 (VCC), U6102.14 (VCC), U6103.14 (VCC); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A2/MUX_OFF: IC501.5 (2Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A2/MUX_ON: IC501.13 (1Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A2/R1: IC501.14 (1CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A2/R2: IC501.6 (2CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A2/RC1: IC501.15 (1CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A2/RC2: IC501.7 (2CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A3/MUX_OFF: IC601.5 (2Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A3/MUX_ON: IC601.13 (1Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A3/R1: IC601.14 (1CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A3/R2: IC601.6 (2CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A3/RC1: IC601.15 (1CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A3/RC2: IC601.7 (2CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A4/MUX_OFF: IC701.5 (2Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A4/MUX_ON: IC701.13 (1Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A4/R1: IC701.14 (1CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A4/R2: IC701.6 (2CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A4/RC1: IC701.15 (1CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 1/MultiVibrator3A4/RC2: IC701.7 (2CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/DIG_OFF_C1: U1202.4; also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/DIG_OFF_C2: U1202.12; also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/DIG_OFF_C3: U1203.4; also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/DIG_OFF_C4: U1203.12; also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/DIG_ON_C1: U1202.1; also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/DIG_ON_C2: U1202.9; also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/DIG_ON_C3: U1203.1; also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/DIG_ON_C4: U1203.9; also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A1/MUX_OFF: IC1301.5 (2Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A1/MUX_ON: IC1301.13 (1Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A1/R1: IC1301.14 (1CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A1/R2: IC1301.6 (2CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A1/RC1: IC1301.15 (1CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A1/RC2: IC1301.7 (2CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A2/MUX_OFF: IC1401.5 (2Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A2/MUX_ON: IC1401.13 (1Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A2/R1: IC1401.14 (1CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A2/R2: IC1401.6 (2CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A2/RC1: IC1401.15 (1CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A2/RC2: IC1401.7 (2CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A3/MUX_OFF: IC1501.5 (2Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A3/MUX_ON: IC1501.13 (1Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A3/R1: IC1501.14 (1CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A3/R2: IC1501.6 (2CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A3/RC1: IC1501.15 (1CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A3/RC2: IC1501.7 (2CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A4/MUX_OFF: IC1601.5 (2Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A4/MUX_ON: IC1601.13 (1Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A4/R1: IC1601.14 (1CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A4/R2: IC1601.6 (2CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A4/RC1: IC1601.15 (1CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 2/MultiVibrator3A4/RC2: IC1601.7 (2CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/DIG_OFF_C1: U2102.4; also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/DIG_OFF_C2: U2102.12; also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/DIG_ON_C1: U2102.1; also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/DIG_ON_C2: U2102.9; also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A1/MUX_OFF: IC2201.5 (2Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A1/MUX_ON: IC2201.13 (1Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A1/R1: IC2201.14 (1CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A1/R2: IC2201.6 (2CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A1/RC1: IC2201.15 (1CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A1/RC2: IC2201.7 (2CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A2/MUX_OFF: IC2301.5 (2Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A2/MUX_ON: IC2301.13 (1Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A2/R1: IC2301.14 (1CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A2/R2: IC2301.6 (2CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A2/RC1: IC2301.15 (1CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A2/RC2: IC2301.7 (2CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A3/MUX_OFF: IC2401.5 (2Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A3/MUX_ON: IC2401.13 (1Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A3/R1: IC2401.14 (1CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A3/R2: IC2401.6 (2CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A3/RC1: IC2401.15 (1CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A3/RC2: IC2401.7 (2CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A4/MUX_OFF: IC2501.5 (2Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A4/MUX_ON: IC2501.13 (1Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A4/R1: IC2501.14 (1CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A4/R2: IC2501.6 (2CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A4/RC1: IC2501.15 (1CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 3/MultiVibrator3A4/RC2: IC2501.7 (2CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/DIG_OFF_C1: U3002.4; also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/DIG_OFF_C2: U3002.12; also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/DIG_OFF_C3: U3003.4; also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/DIG_OFF_C4: U3003.12; also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/DIG_ON_C1: U3002.1; also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/DIG_ON_C2: U3002.9; also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/DIG_ON_C3: U3003.1; also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/DIG_ON_C4: U3003.9; also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A1/MUX_OFF: IC3101.5 (2Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A1/MUX_ON: IC3101.13 (1Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A1/R1: IC3101.14 (1CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A1/R2: IC3101.6 (2CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A1/RC1: IC3101.15 (1CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A1/RC2: IC3101.7 (2CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A2/MUX_OFF: IC3201.5 (2Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A2/MUX_ON: IC3201.13 (1Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A2/R1: IC3201.14 (1CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A2/R2: IC3201.6 (2CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A2/RC1: IC3201.15 (1CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A2/RC2: IC3201.7 (2CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A3/MUX_OFF: IC3301.5 (2Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A3/MUX_ON: IC3301.13 (1Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A3/R1: IC3301.14 (1CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A3/R2: IC3301.6 (2CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A3/RC1: IC3301.15 (1CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A3/RC2: IC3301.7 (2CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A4/MUX_OFF: IC3401.5 (2Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A4/MUX_ON: IC3401.13 (1Q); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A4/R1: IC3401.14 (1CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A4/R2: IC3401.6 (2CX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A4/RC1: IC3401.15 (1CXRX); also elsewhere on the board
/12V DC Common Bank/12V DC Block 4/MultiVibrator3A4/RC2: IC3401.7 (2CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/DIG_OFF_C1: U4002.4; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/DIG_OFF_C2: U4002.12; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/DIG_OFF_C3: U4003.4; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/DIG_OFF_C4: U4003.12; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/DIG_ON_C1: U4002.1; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/DIG_ON_C2: U4002.9; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/DIG_ON_C3: U4003.1; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/DIG_ON_C4: U4003.9; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/MultiVibrator6A1/MUX_OFF: IC5301.5 (2Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/MultiVibrator6A1/MUX_ON: IC5301.13 (1Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/MultiVibrator6A1/RC1: IC5301.15 (1CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/MultiVibrator6A1/RC2: IC5301.7 (2CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/MultiVibrator6A2/MUX_OFF: IC5401.5 (2Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/MultiVibrator6A2/MUX_ON: IC5401.13 (1Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/MultiVibrator6A2/RC1: IC5401.15 (1CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/MultiVibrator6A2/RC2: IC5401.7 (2CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/MultiVibrator6A3/MUX_OFF: IC5501.5 (2Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/MultiVibrator6A3/MUX_ON: IC5501.13 (1Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/MultiVibrator6A3/RC1: IC5501.15 (1CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/MultiVibrator6A3/RC2: IC5501.7 (2CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/MultiVibrator6A4/MUX_OFF: IC5601.5 (2Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/MultiVibrator6A4/MUX_ON: IC5601.13 (1Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/MultiVibrator6A4/RC1: IC5601.15 (1CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 6A Block/MultiVibrator6A4/RC2: IC5601.7 (2CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator10A1/MUX_O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: IC7101.5 (2Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator10A1/MUX_ON: IC7101.13 (1Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator10A1/R1: IC7101.14 (1CX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator10A1/R2: IC7101.6 (2CX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator10A1/RC1: IC7101.15 (1CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator10A1/RC2: IC7101.7 (2CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator10A2/MUX_O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: IC7201.5 (2Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator10A2/MUX_ON: IC7201.13 (1Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator10A2/R1: IC7201.14 (1CX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator10A2/R2: IC7201.6 (2CX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator10A2/RC1: IC7201.15 (1CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator10A2/RC2: IC7201.7 (2CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator16A1/MUX_O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: IC7301.5 (2Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator16A1/MUX_ON: IC7301.13 (1Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator16A1/R1: IC7301.14 (1CX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator16A1/R2: IC7301.6 (2CX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator16A1/RC1: IC7301.15 (1CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator16A1/RC2: IC7301.7 (2CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator16A2/MUX_O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: IC7401.5 (2Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator16A2/MUX_ON: IC7401.13 (1Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator16A2/R1: IC7401.14 (1CX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator16A2/R2: IC7401.6 (2CX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator16A2/RC1: IC7401.15 (1CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/12V DC 10/16A Block/MultiVibrator16A2/RC2: IC7401.7 (2CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/MultiVibrator6A1/MUX_OFF: IC8001.5 (2Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/MultiVibrator6A1/MUX_ON: IC8001.13 (1Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/MultiVibrator6A1/RC1: IC8001.15 (1CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/MultiVibrator6A1/RC2: IC8001.7 (2CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/MultiVibrator6A2/MUX_OFF: IC8101.5 (2Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/MultiVibrator6A2/MUX_ON: IC8101.13 (1Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/MultiVibrator6A2/RC1: IC8101.15 (1CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/MultiVibrator6A2/RC2: IC8101.7 (2CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/MultiVibrator6A3/MUX_OFF: IC8201.5 (2Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/MultiVibrator6A3/MUX_ON: IC8201.13 (1Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/MultiVibrator6A3/RC1: IC8201.15 (1CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/MultiVibrator6A3/RC2: IC8201.7 (2CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/MultiVibrator6A4/MUX_OFF: IC8301.5 (2Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/MultiVibrator6A4/MUX_ON: IC8301.13 (1Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/MultiVibrator6A4/RC1: IC8301.15 (1CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 6A Block/MultiVibrator6A4/RC2: IC8301.7 (2CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/DIG_OFF_C1: U6102.4; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/DIG_OFF_C2: U6102.12; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/DIG_OFF_C3: U6103.4; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/DIG_OFF_C4: U6103.12; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/DIG_ON_C1: U6102.1; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/DIG_ON_C2: U6102.9; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/DIG_ON_C3: U6103.1; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/DIG_ON_C4: U6103.9; also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator10A1/MUX_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: IC6201.5 (2Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator10A1/MUX_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: IC6201.13 (1Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator10A1/R1: IC6201.14 (1CX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator10A1/R2: IC6201.6 (2CX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator10A1/RC1: IC6201.15 (1CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator10A1/RC2: IC6201.7 (2CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator10A2/MUX_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: IC6301.5 (2Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator10A2/MUX_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: IC6301.13 (1Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator10A2/R1: IC6301.14 (1CX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator10A2/R2: IC6301.6 (2CX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator10A2/RC1: IC6301.15 (1CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator10A2/RC2: IC6301.7 (2CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator16A1/MUX_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: IC6401.5 (2Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator16A1/MUX_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: IC6401.13 (1Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator16A1/R1: IC6401.14 (1CX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator16A1/R2: IC6401.6 (2CX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator16A1/RC1: IC6401.15 (1CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator16A1/RC2: IC6401.7 (2CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator16A2/MUX_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: IC6501.5 (2Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator16A2/MUX_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: IC6501.13 (1Q); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator16A2/R1: IC6501.14 (1CX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator16A2/R2: IC6501.6 (2CX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator16A2/RC1: IC6501.15 (1CXRX); also elsewhere on the board
/Mixed 12V DC / 230V AC Common Bank/230V AC 10/16A Block/MultiVibrator16A2/RC2: IC6501.7 (2CXRX); also elsewhere on the board
GND: C501.2, C601.2, C602.1, C603.1, C701.2, C1301.2, C1302.1, C1303.1, C1401.2, C1501.2, C1502.1, C1503.1, C1601.2, C2201.2, C2202.1, C2203.1, C2301.2, C2401.2, C2402.1, C2403.1, C2501.2, C3101.2, C3102.1, C3103.1, C3201.2, C3301.2, C3302.1, C3303.1, C3401.2, C5301.2, C5302.1, C5303.1, C5401.2, C5501.2, C5502.1, C5503.1, C5601.2, C6201.2, C6202.1, C6203.1, C6301.2, C6401.2, C6402.1, C6403.1, C6501.2, C7101.2, C7102.1, C7103.1, C7201.2, C7301.2, C7302.1, C7303.1, C7401.2, C8001.2, C8002.1, C8003.1, C8101.2, C8201.2, C8202.1, C8203.1, C8301.2, IC501.1 (~1A), IC501.8 (GND), IC501.9 (~2A), IC601.1 (~1A), IC601.8 (GND), IC601.9 (~2A), IC701.1 (~1A), IC701.8 (GND), IC701.9 (~2A), IC1301.1 (~1A), IC1301.8 (GND), IC1301.9 (~2A), IC1401.1 (~1A), IC1401.8 (GND), IC1401.9 (~2A), IC1501.1 (~1A), IC1501.8 (GND), IC1501.9 (~2A), IC1601.1 (~1A), IC1601.8 (GND), IC1601.9 (~2A), IC2201.1 (~1A), IC2201.8 (GND), IC2201.9 (~2A), IC2301.1 (~1A), IC2301.8 (GND), IC2301.9 (~2A), IC2401.1 (~1A), IC2401.8 (GND), IC2401.9 (~2A), IC2501.1 (~1A), IC2501.8 (GND), IC2501.9 (~2A), IC3101.1 (~1A), IC3101.8 (GND), IC3101.9 (~2A), IC3201.1 (~1A), IC3201.8 (GND), IC3201.9 (~2A), IC3301.1 (~1A), IC3301.8 (GND), IC3301.9 (~2A), IC3401.1 (~1A), IC3401.8 (GND), IC3401.9 (~2A), IC5301.1 (~1A), IC5301.8 (GND), IC5301.9 (~2A), IC5401.1 (~1A), IC5401.8 (GND), IC5401.9 (~2A), IC5501.1 (~1A), IC5501.8 (GND), IC5501.9 (~2A), IC5601.1 (~1A), IC5601.8 (GND), IC5601.9 (~2A), IC6201.1 (~1A), IC6201.8 (GND), IC6201.9 (~2A), IC6301.1 (~1A), IC6301.8 (GND), IC6301.9 (~2A), IC6401.1 (~1A), IC6401.8 (GND), IC6401.9 (~2A), IC6501.1 (~1A), IC6501.8 (GND), IC6501.9 (~2A), IC7101.1 (~1A), IC7101.8 (GND), IC7101.9 (~2A), IC7201.1 (~1A), IC7201.8 (GND), IC7201.9 (~2A), IC7301.1 (~1A), IC7301.8 (GND), IC7301.9 (~2A), IC7401.1 (~1A), IC7401.8 (GND), IC7401.9 (~2A), IC8001.1 (~1A), IC8001.8 (GND), IC8001.9 (~2A), IC8101.1 (~1A), IC8101.8 (GND), IC8101.9 (~2A), IC8201.1 (~1A), IC8201.8 (GND), IC8201.9 (~2A), IC8301.1 (~1A), IC8301.8 (GND), IC8301.9 (~2A), U1202.7 (GND), U1203.7 (GND), U2102.7 (GND), U3002.7 (GND), U3003.7 (GND), U4002.7 (GND), U4003.7 (GND), U6102.7 (GND), U6103.7 (GND); also elsewhere on the board
unnamed: IC501.4 (~1Q), IC501.11 (~2R)
unnamed: IC501.3 (~1R), IC501.12 (~2Q)
unnamed 926: IC601.2 (1B); also elsewhere on the board
unnamed 927: IC601.10 (2B); also elsewhere on the board
unnamed: IC601.4 (~1Q), IC601.11 (~2R)
unnamed: IC601.3 (~1R), IC601.12 (~2Q)
unnamed 930: IC701.2 (1B); also elsewhere on the board
unnamed 931: IC701.10 (2B); also elsewhere on the board
unnamed: IC701.4 (~1Q), IC701.11 (~2R)
unnamed: IC701.3 (~1R), IC701.12 (~2Q)
unnamed: IC1301.2 (1B), U1202.3
unnamed: IC1301.10 (2B), U1202.6
unnamed: IC1301.4 (~1Q), IC1301.11 (~2R)
unnamed: IC1301.3 (~1R), IC1301.12 (~2Q)
unnamed: IC1401.2 (1B), U1202.8
unnamed: IC1401.10 (2B), U1202.11
unnamed: IC1401.4 (~1Q), IC1401.11 (~2R)
unnamed: IC1401.3 (~1R), IC1401.12 (~2Q)
unnamed: IC1501.2 (1B), U1203.3
unnamed: IC1501.10 (2B), U1203.6
unnamed: IC1501.4 (~1Q), IC1501.11 (~2R)
unnamed: IC1501.3 (~1R), IC1501.12 (~2Q)
unnamed: IC1601.2 (1B), U1203.8
unnamed: IC1601.10 (2B), U1203.11
unnamed: IC1601.4 (~1Q), IC1601.11 (~2R)
unnamed: IC1601.3 (~1R), IC1601.12 (~2Q)
unnamed: IC2201.2 (1B), U2102.3
unnamed: IC2201.10 (2B), U2102.6
unnamed: IC2201.4 (~1Q), IC2201.11 (~2R)
unnamed: IC2201.3 (~1R), IC2201.12 (~2Q)
unnamed: IC2301.2 (1B), U2102.8
unnamed: IC2301.10 (2B), U2102.11
unnamed: IC2301.4 (~1Q), IC2301.11 (~2R)
unnamed: IC2301.3 (~1R), IC2301.12 (~2Q)
unnamed: IC2401.4 (~1Q), IC2401.11 (~2R)
unnamed: IC2401.3 (~1R), IC2401.12 (~2Q)
unnamed 960: IC2501.2 (1B); also elsewhere on the board
unnamed 961: IC2501.10 (2B); also elsewhere on the board
unnamed: IC2501.4 (~1Q), IC2501.11 (~2R)
unnamed: IC2501.3 (~1R), IC2501.12 (~2Q)
unnamed: IC3101.2 (1B), U3002.3
unnamed: IC3101.10 (2B), U3002.6
unnamed: IC3101.4 (~1Q), IC3101.11 (~2R)
unnamed: IC3101.3 (~1R), IC3101.12 (~2Q)
unnamed: IC3201.2 (1B), U3002.8
unnamed: IC3201.10 (2B), U3002.11
unnamed: IC3201.4 (~1Q), IC3201.11 (~2R)
unnamed: IC3201.3 (~1R), IC3201.12 (~2Q)
unnamed: IC3301.2 (1B), U3003.3
unnamed: IC3301.10 (2B), U3003.6
unnamed: IC3301.4 (~1Q), IC3301.11 (~2R)
unnamed: IC3301.3 (~1R), IC3301.12 (~2Q)
unnamed: IC3401.2 (1B), U3003.8
unnamed: IC3401.10 (2B), U3003.11
unnamed: IC3401.4 (~1Q), IC3401.11 (~2R)
unnamed: IC3401.3 (~1R), IC3401.12 (~2Q)
unnamed: IC5301.2 (1B), U4002.3
unnamed: IC5301.10 (2B), U4002.6
unnamed: IC5301.4 (~1Q), IC5301.11 (~2R)
unnamed: IC5301.3 (~1R), IC5301.12 (~2Q)
unnamed: IC5401.2 (1B), U4002.8
unnamed: IC5401.10 (2B), U4002.11
unnamed: IC5401.4 (~1Q), IC5401.11 (~2R)
unnamed: IC5401.3 (~1R), IC5401.12 (~2Q)
unnamed: IC5501.2 (1B), U4003.3
unnamed: IC5501.10 (2B), U4003.6
unnamed: IC5501.4 (~1Q), IC5501.11 (~2R)
unnamed: IC5501.3 (~1R), IC5501.12 (~2Q)
unnamed: IC5601.2 (1B), U4003.8
unnamed: IC5601.10 (2B), U4003.11
unnamed: IC5601.4 (~1Q), IC5601.11 (~2R)
unnamed: IC5601.3 (~1R), IC5601.12 (~2Q)
unnamed: IC6201.2 (1B), U6102.3
unnamed: IC6201.10 (2B), U6102.6
unnamed: IC6201.4 (~1Q), IC6201.11 (~2R)
unnamed: IC6201.3 (~1R), IC6201.12 (~2Q)
unnamed: IC6301.2 (1B), U6102.8
unnamed: IC6301.10 (2B), U6102.11
unnamed: IC6301.4 (~1Q), IC6301.11 (~2R)
unnamed: IC6301.3 (~1R), IC6301.12 (~2Q)
unnamed: IC6401.2 (1B), U6103.3
unnamed: IC6401.10 (2B), U6103.6
unnamed: IC6401.4 (~1Q), IC6401.11 (~2R)
unnamed: IC6401.3 (~1R), IC6401.12 (~2Q)
unnamed: IC6501.2 (1B), U6103.8
unnamed: IC6501.10 (2B), U6103.11
unnamed: IC6501.4 (~1Q), IC6501.11 (~2R)
unnamed: IC6501.3 (~1R), IC6501.12 (~2Q)
unnamed 1012: IC7101.2 (1B); also elsewhere on the board
unnamed 1013: IC7101.10 (2B); also elsewhere on the board
unnamed: IC7101.4 (~1Q), IC7101.11 (~2R)
unnamed: IC7101.3 (~1R), IC7101.12 (~2Q)
unnamed 1016: IC7201.2 (1B); also elsewhere on the board
unnamed 1017: IC7201.10 (2B); also elsewhere on the board
unnamed: IC7201.4 (~1Q), IC7201.11 (~2R)
unnamed: IC7201.3 (~1R), IC7201.12 (~2Q)
unnamed 1020: IC7301.2 (1B); also elsewhere on the board
unnamed 1021: IC7301.10 (2B); also elsewhere on the board
unnamed: IC7301.4 (~1Q), IC7301.11 (~2R)
unnamed: IC7301.3 (~1R), IC7301.12 (~2Q)
unnamed 1024: IC7401.2 (1B); also elsewhere on the board
unnamed 1025: IC7401.10 (2B); also elsewhere on the board
unnamed: IC7401.4 (~1Q), IC7401.11 (~2R)
unnamed: IC7401.3 (~1R), IC7401.12 (~2Q)
unnamed 1028: IC8001.2 (1B); also elsewhere on the board
unnamed 1029: IC8001.10 (2B); also elsewhere on the board
unnamed: IC8001.4 (~1Q), IC8001.11 (~2R)
unnamed: IC8001.3 (~1R), IC8001.12 (~2Q)
unnamed 1032: IC8101.2 (1B); also elsewhere on the board
unnamed 1033: IC8101.10 (2B); also elsewhere on the board
unnamed: IC8101.4 (~1Q), IC8101.11 (~2R)
unnamed: IC8101.3 (~1R), IC8101.12 (~2Q)
unnamed 1036: IC8201.2 (1B); also elsewhere on the board
unnamed 1037: IC8201.10 (2B); also elsewhere on the board
unnamed: IC8201.4 (~1Q), IC8201.11 (~2R)
unnamed: IC8201.3 (~1R), IC8201.12 (~2Q)
unnamed 1040: IC8301.2 (1B); also elsewhere on the board
unnamed 1041: IC8301.10 (2B); also elsewhere on the board
unnamed: IC8301.4 (~1Q), IC8301.11 (~2R)
unnamed: IC8301.3 (~1R), IC8301.12 (~2Q)

Notes on the sheet:
Signals can be either momentary or latching. Both analogue and digital inputs are pulled low using 100k resistors. "ON" signals cancel "OFF" signals and vice versa to prevent both coils from being powered at the same time.
ON side
OFF side
